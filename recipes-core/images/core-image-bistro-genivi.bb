#
#   Copyright (C) 2015 Pelagicore AB
#
DESCRIPTION = "Image for creating a small bootable Bistro-based image with GENIVI components"

require core-image-bistro.bb
require core-image-bistro-genivi.inc
