SRC_URI += "file://ikconfig.cfg"
