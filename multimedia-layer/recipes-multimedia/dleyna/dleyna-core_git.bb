#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
DESCRIPTION = "dLeyna Core"
require dleyna-git.inc
SRCREV = "20c77a2554d6f170e541ac490e343c532bdfc53e"