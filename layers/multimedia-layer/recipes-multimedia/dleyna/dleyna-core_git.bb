#
#   Copyright (C) 2015 Pelagicore AB
#
DESCRIPTION = "dLeyna Core"
require dleyna-git.inc
SRCREV = "d161d1616d4cb32a8c1e23a0587ee37e3ab0deb0"
