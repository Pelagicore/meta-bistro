#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
DESCRIPTION = "dLeyna Connector DBus"
DEPENDS = "dleyna-core"
require dleyna-git.inc
PV = "0.2.0+git${SRCPV}"
SRCREV = "525e167b4699b3fa84bf44830a37db128e640c5b"
