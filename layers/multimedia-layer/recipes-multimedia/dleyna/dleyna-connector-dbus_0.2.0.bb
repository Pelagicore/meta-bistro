#
#   Copyright (C) 2015 Pelagicore AB
#
DESCRIPTION = "dLeyna Connector DBus"
DEPENDS = "dleyna-core"

require dleyna.inc

SRC_URI[md5sum] = "04c2425239d092f4da457c061be7aa81"
SRC_URI[sha256sum] = "e791511206761282a658bb8253de076dcb1f8c8fbdc81219efe5ffe80cb2bea5"

