#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
PACKAGECONFIG += "gstreamer010"
