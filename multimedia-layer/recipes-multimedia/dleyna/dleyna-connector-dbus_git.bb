#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
DESCRIPTION = "dLeyna Connector DBus"
DEPENDS = "dleyna-core"
require dleyna-git.inc
PV = "0.2.0+git${SRCPV}"
SRCREV = "d1ca461ad859615cf07df677e7c98b942a1b992e"