#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#

require core-image-bistro-sdk-1.0.bb
require core-image-bistro-ivi.bb
