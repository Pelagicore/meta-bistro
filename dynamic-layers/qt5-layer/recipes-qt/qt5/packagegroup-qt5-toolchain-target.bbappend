#
#   Copyright (C) 2015 Pelagicore AB
#
#   SPDX-License-Identifier: MIT
#
RDEPENDS_${PN}_remove = "qtsystems-dev qtsystems-qmlplugins qtsystems-mkspecs qttools-plugins"
