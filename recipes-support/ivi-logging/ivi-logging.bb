#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
require ${PN}.inc

SRC_URI = "${GIT_REPO};branch=master"
SRCREV = "2367a29a413fb18dc8af4d9fe41620e1b5faaf15"
PV = "0.1+git${SRCREV}"
