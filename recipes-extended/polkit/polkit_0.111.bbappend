#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
# Needed since the default meta-oe value is consolekit
POLKITAUTH = "systemd"
