#
#   Copyright (C) 2015 Pelagicore AB
#
# Build without XKB
XKB_DEPENDS = ""
