#
#   Copyright (C) 2015 Pelagicore AB
#
DESCRIPTION = "Image for creating a small bootable Bistro-based development image with GENIVI components"

require core-image-bistro-dev.bb
require core-image-bistro-genivi.inc
