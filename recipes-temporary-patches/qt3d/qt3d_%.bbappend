#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#

# Master branch was removed upstream. This file should be removed when
# meta-qt5 layer has been updated to reflect that.
QT_MODULE_BRANCH = "dev"
