#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
RDEPENDS_${PN}_remove = "qtsystems-dev qtsystems-qmlplugins qtsystems-mkspecs "
USE_RUBY_remove = "qttools-plugins"
