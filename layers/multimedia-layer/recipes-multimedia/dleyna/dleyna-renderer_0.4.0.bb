#
#   Copyright (C) 2015 Pelagicore AB
#
DESCRIPTION = "dLeyna Renderer"
DEPENDS = "dleyna-core"
require dleyna.inc

SRC_URI[md5sum] = "7f7c45f1c13217b0482d17ce20315e09"
SRC_URI[sha256sum] = "16c84e67f8308a1c825d966b02b6dcbd2dec09ea8dd3d4a59a47e8f6507863b3"

