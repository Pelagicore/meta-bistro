#
#   Copyright (C) 2015 Pelagicore AB
#
DESCRIPTION = "dLeyna Core"
require dleyna.inc

SRC_URI[md5sum] = "b283c5f9f70bb5b736f0167b60d72f87"
SRC_URI[sha256sum] = "b39d98a79dcce82d4d4b7f932ffed98e97c46a361a43985c2eb1ad54db84c183"

