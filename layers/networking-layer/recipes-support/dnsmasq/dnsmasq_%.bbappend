#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
SYSTEMD_AUTO_ENABLE = "disable"
