#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
PACKAGECONFIG[bluetooth] = "--enable-bluetooth, --disable-bluetooth, bluez5"
