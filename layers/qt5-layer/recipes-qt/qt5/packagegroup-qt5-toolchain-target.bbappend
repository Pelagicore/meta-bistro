#
#   Copyright (C) 2015 Pelagicore AB
#
RDEPENDS_${PN}_remove = "qtsystems-dev qtsystems-qmlplugins qtsystems-mkspecs qttools-plugins"
