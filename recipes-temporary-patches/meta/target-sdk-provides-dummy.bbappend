DUMMYPROVIDES += " \
    perl-module-overload \
"
