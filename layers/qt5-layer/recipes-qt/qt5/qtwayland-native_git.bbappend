#
#   Copyright (C) 2015 Pelagicore AB
#   All rights reserved.
#
QT_MODULE_BRANCH="dev"
