
require gdbus-codegen-glibmm.inc

SRC_URI = "https://github.com/Pelagicore/gdbus-codegen-glibmm.git"
SRCREV = "c4ed6e0f6cdc21d41503e8312108e21715dceb2d"
