PACKAGECONFIG_append = " nghttp2 "
PACKAGECONFIG_remove_class-native = " nghttp2 "
PACKAGECONFIG_remove_class-nativesdk = " nghttp2 "
