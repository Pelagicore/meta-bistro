#
#   Copyright (C) 2015 Pelagicore AB
#
# Needed since the default meta-oe value is consolekit
POLKITAUTH = "systemd"
