#
#   Copyright (C) 2015 Pelagicore AB
#

FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI += "file://0001-Adds-correct-DBus-libraries-path-if-installed-outsid.patch \
            file://0001-Adds-required-dependencies-to-pc-file.patch"

