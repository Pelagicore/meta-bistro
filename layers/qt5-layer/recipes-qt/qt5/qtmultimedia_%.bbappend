#
#   Copyright (C) 2015 Pelagicore AB
#
#   SPDX-License-Identifier: MIT
#

PACKAGECONFIG += " \
    gstreamer \
"
