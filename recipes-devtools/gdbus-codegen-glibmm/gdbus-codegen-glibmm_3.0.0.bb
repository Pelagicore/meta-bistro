
require gdbus-codegen-glibmm.inc

SRC_URI = "https://github.com/Pelagicore/gdbus-codegen-glibmm.git"
SRCREV = "97a09be277e1cbf2716ae633e87c010cff1f4d10"
